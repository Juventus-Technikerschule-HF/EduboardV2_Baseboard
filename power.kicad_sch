File: power.kicad_sch (KiCad schematic)
At the start: 35 parts, among them IC301 XL1509-5.0E1

Commit message: added more components
Parts:
- gave numbers to parts that had none: 34
